# Keil uVision project Hoverboard.uvprojx, settings and files
target GD32F130C8 (6210000::V6.21::ARMCLANG)
  device: GD32F130C8 GigaDevice
  pack: GigaDevice.GD32F1x0_DFP.3.2.1
  cpu: IRAM(0x20000000,0x02000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Hoverboard +hex
  AfterMake: fromelf.exe --bin Objects\hoverboard.axf --output BinariesToFlash\hoverboard.bin
  AfterMake: moveOutput.bat
  c flags: Optim=2 v6Lang=1 v6LangP=5 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Src
    ./Src/: main.c bldc.c setup.c it.c led.c
  group Inc
    ./Inc/: config.h setup.h bldc.h it.h led.h target.h defines.h defines_2-0.h defines_2-1.h defines_2-2.h defines_2-3.h defines_2-4.h defines_2-6.h defines_2-7.h defines_2-8.h defines_2-10.h defines_2-11.h defines_2-13.h defines_2-14.h defines_2-15.h defines_2-16.h defines_2-17.h defines_2-x.h remote.h remoteDummy.h
target GD32E230C8T6 (6210000::V6.21::ARMCLANG)
  device: GD32E230C8 GigaDevice
  pack: GigaDevice.GD32E23x_DFP.1.0.2
  cpu: IRAM(0x20000000,0x0002000) IROM(0x08000000,0x0010000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: Hoverboard +hex
  AfterMake: as above
  AfterMake: moveOutput.bat
  c flags: Optim=2 v6Lang=1 v6LangP=5 wLevel=3
  c define: GD32E230
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
target MM32SPIN05 (6210000::V6.21::ARMCLANG)
  device: MM32SPIN05PF MindMotion
  pack: MindMotion.MM32SPIN0x_DFP.1.0.8
  cpu: IRAM(0x20000000,0x1000) IROM(0x08000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Hoverboard +hex
  AfterMake: as above
  AfterMake: moveOutput.bat
  c flags: Optim=2 v6Lang=1 v6LangP=5 wLevel=3
  c define: MM32SPIN05
  c include: .\RTE\IncludeMM32;.\Device\MM32SPIN0x_q\HAL_Lib\Inc;.\Device\CMSIS\KEIL_Core
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
software components: CMSIS:CORE 5.6.0, Device:GD32E23x_StdPeripherals:ADC 1.0.0, Device:GD32E23x_StdPeripherals:DMA 1.0.0, Device:GD32E23x_StdPeripherals:FMC 1.0.0, Device:GD32E23x_StdPeripherals:FWDGT 1.0.0, Device:GD32E23x_StdPeripherals:GPIO 1.0.0, Device:GD32E23x_StdPeripherals:I2C 1.0.0, Device:GD32E23x_StdPeripherals:MISC 1.0.0, Device:GD32E23x_StdPeripherals:PMU 1.0.0, Device:GD32E23x_StdPeripherals:RCU 1.0.0, Device:GD32E23x_StdPeripherals:SYSCFG 1.0.0, Device:GD32E23x_StdPeripherals:TIMER 1.0.0, Device:GD32E23x_StdPeripherals:USART 1.0.0, Device:GD32E23x_StdPeripherals:WWDGT 1.0.0, Device:GD32E23x_libopt 1.0.0, Device:GD32F1x0_StdPeripherals:ADC 3.2.0, Device:GD32F1x0_StdPeripherals:DMA 3.2.0, Device:GD32F1x0_StdPeripherals:FWDGT 3.2.0, Device:GD32F1x0_StdPeripherals:GPIO 3.2.0, Device:GD32F1x0_StdPeripherals:I2C 3.2.0, Device:GD32F1x0_StdPeripherals:MCUDBG 3.2.0, Device:GD32F1x0_StdPeripherals:MISC 3.2.0, Device:GD32F1x0_StdPeripherals:OPA 3.2.0, Device:GD32F1x0_StdPeripherals:PMU 3.2.0, Device:GD32F1x0_StdPeripherals:RCU 3.2.0, Device:GD32F1x0_StdPeripherals:SYSCFG 3.2.0, Device:GD32F1x0_StdPeripherals:TIMER 3.2.0, Device:GD32F1x0_StdPeripherals:USART 3.2.0, Device:GD32F1x0_StdPeripherals:WWDGT 3.2.0, Device:GD32F1x0_libopt 3.2.0, Device:Startup 1.0.0, Device:Startup 3.2.0, Device:Startup 1.0.0
